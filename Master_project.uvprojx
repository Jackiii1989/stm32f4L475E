# Keil uVision project Master_project.uvprojx, settings and files
target First_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: First_stand_alone_program
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c misc: --C99
  c include: .\drivers;.\inc\Application layer;.\inc\Middle layer;.\inc\Basic layer;.\inc\CPU specific
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application layer
    ./src/Application layer/: main.c
  group Middle layer
    ./src/Middle layer/: HTS221.c PWM_example.c ISM43362.c
  group Basic Layer
    ./src/Basic layer/: gpio.c InitFunctions.c i2c.c rcc.c usart.c tim.c rtc.c nvic.c spi.c
  group StartUp
    ./drivers/: startup_stm32l475xx.s
  group CPU specific
    ./src/CPU specific/: m4core.c stm32l4xx_it.c
